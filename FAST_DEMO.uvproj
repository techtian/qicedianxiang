# Keil uVision project FAST_DEMO.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: FAST_DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group STARTUP
    ./STARTUP/: STARTUP.A51
  group INC
    ./inc/: STC15.h uart1.h system.h
  group SRC
    ./src/: main.c uart1.c system.c
